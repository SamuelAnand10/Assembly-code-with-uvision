# Keil uVision project testeeeeeeeeeer.uvproj, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LH75400 NXP
  cpu: IRAM(0x60000000-0x60003FFF) XRAM(0x80000000-0x80003FFF) CLOCK(14745600) CPUTYPE(ARM7TDMI)
  output: testeeeeeeeeeer
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT6: ROM 0x80000000 size 0x4000
  memory RVCT9: RAM 0x60000000 size 0x4000
  group Source Group 1
    ./: que.s lab 2.s lab 2 Q2.s
